options:
  parameters:
    author: Gulherme Sousa Ferreira
    copyright: (c)  2025
    generate_options: hb
    id: wap2_decryptor_hier
    max_nouts: '1'
    output_language: python
    title: WPA2 Decryptor
  states: {}

blocks:
- name: password
  id: parameter
  parameters:
    label: Password
    type: str
    value: '''password'''
  states: {}
- name: ssid
  id: parameter
  parameters:
    label: SSID
    type: str
    value: '''ssid'''
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Wrapper for WPA2 Decryptor
      """
      import numpy as np
      from gnuradio import gr
      import sys
      import os
      import importlib

      # --- CONFIGURATION ---
      # Since __file__ is not defined in GRC, you must hardcode the folder path
      # Replace this string with the result of 'pwd' in your terminal
      path_to_my_folder = '/home/guilherme/github/gr-blocks/' 
      # ---------------------

      # 1. Add that folder to Python path
      if path_to_my_folder not in sys.path:
          sys.path.append(path_to_my_folder)

      # 2. Import the external module
      try:
          import wpa2_decryption
      except ImportError as e:
          print(f"[Error] Could not find wpa2_decryption.py in {path_to_my_folder}")
          raise e

      # 3. Reload it (for development)
      if 'wpa2_decryption' in sys.modules:
          importlib.reload(wpa2_decryption)

      class blk(wpa2_decryption.wpa_decrypt_block):
          def __init__(self, password="password", ssid="ssid"):
              # Initialize the base class from your external file
              wpa2_decryption.wpa_decrypt_block.__init__(self, password, ssid)
    password: password
    ssid: ssid
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}

connections:
- [epy_block_0, out, pad_sink_0, in]
- [pad_source_0, out, epy_block_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
