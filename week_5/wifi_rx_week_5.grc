options:
  parameters:
    generate_options: qt_gui
    id: main_proj_wifi_rx
    output_language: python
    title: Wifi RX SDR
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_chooser
  parameters:
    label0: 5G high offset
    label1: 5G low offset
    label2: 2.4G high offset
    label3: 2.4G low offset
    num_opts: '4'
    option0: '5220000000'
    option1: '5180000000'
    option2: '2420000000'
    option3: '2380000000'
    type: real
    value: '5180000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: update_period
  id: variable_qtgui_chooser
  parameters:
    label0: 1ms
    label1: 10ms
    label2: 1s
    label3: 5s
    label4: 10s
    num_opts: '5'
    option0: '1e-3'
    option1: '1e-2'
    option2: '1'
    option3: '5'
    option4: '10'
    type: real
    value: '1'
  states: {}
- name: window_size
  id: variable_qtgui_chooser
  parameters:
    label: window_size
    label0: '16'
    label1: '32'
    label2: '48'
    label3: '64'
    label4: '96'
    num_opts: '5'
    option0: '16'
    option1: '32'
    option2: '48'
    option3: '64'
    option4: '96'
    type: int
    value: '48'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/guilherme/Desktop/MEEC/DigitalCommunications/MainProject/week_3/my_recording_pluto.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/guilherme/Desktop/MEEC/DigitalCommunications/MainProject/Wifi_Project_Baseband_recordings/Sample1_20MHz_Channel36.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/guilherme/Desktop/MEEC/DigitalCommunications/MainProject/Wifi_Project_Baseband_recordings/Sample2_20MHz_Channel6.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_2
  id: blocks_file_source
  parameters:
    file: /home/guilherme/Desktop/MEEC/DigitalCommunications/MainProject/Wifi_Project_Baseband_recordings/Sample3_20MHz_Channel100.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    type: complex
  states: {state: disabled}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * window_size'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccf
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '127'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_frequency
    freq_span: samp_rate
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    bw: 20e6
    debug: 'False'
    freq: center_frequency
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'True'
    log: 'True'
    min_plateau: '2'
    threshold: '0.8'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_frequency
    gain1: '''manual'''
    manual_gain1: '20'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: update_period
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    plottime: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '2048'
    plottime: 'False'
    rate: update_period
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '2048'
    plottime: 'False'
    rate: update_period
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: yellow
    grid: 'True'
    name: '"Autocorrelation Plot"'
    size: '512'
    srate: '1'
    style1: '2'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: update_period
    ylabel: Autocorrelation
    ymin: '0'
    yunit: '"Power"'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: yellow
    grid: 'True'
    name: '"Autocorrelation Plot"'
    size: '512'
    srate: '1'
    style1: '2'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: update_period
    ylabel: Autocorrelation
    ymin: '0'
    yunit: '"Power"'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    type: complex
    update_time: update_period
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_1, '0', blocks_throttle2_0, '0']
- [blocks_file_source_2, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_to_stream_1, '0', qtgui_const_sink_x_0_0_1, '0']
- [fft_vxx_1, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_divide_xx_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', ieee802_11_sync_short_0, '1']
- [fir_filter_xxx_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_sink_x_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_0, out, network_socket_pdu_0, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_long_0, '0', fosphor_qt_sink_c_0, '0']
- [ieee802_11_sync_long_0, '0', qtgui_freq_sink_x_0, '0']
- [ieee802_11_sync_long_0, '0', qtgui_sink_x_0_0_0, '0']
- [ieee802_11_sync_long_0, '0', qtgui_waterfall_sink_x_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [ieee802_11_sync_short_0, '0', qtgui_const_sink_x_0_0, '0']
- [ieee802_11_sync_short_0, '0', qtgui_sink_x_0_0, '0']
- [ieee802_11_sync_short_0, '0', qtgui_time_sink_x_0_1, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']
- [network_socket_pdu_0, pdus, foo_wireshark_connector_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
